# IAR project NXPCar2018.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 NXP MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\Myfile; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB; ..\..\Prj\IAR\Ucgui\ConvertColor; ..\..\Prj\IAR\Ucgui\GUI\ConvertMono; ..\..\Prj\IAR\Ucgui\GUI\Core; ..\..\Prj\IAR\Ucgui\GUI\Font; ..\..\Prj\IAR\Ucgui\GUI\LCDDriver; ..\..\Prj\IAR\Ucgui\GUI\WM; ..\..\Prj\IAR\Ucgui\Config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NXPCar2018.hex
  ILINK.IlinkOutputFile: NXPCar2018.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N1M.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 3
  group App
    ../../App/Inc/: include.h MK60_conf.h MK60_it.h PORT_cfg.h
    ../../App/: main.c MK60_conf.c MK60_it.c
  group Board
    ../../Board/src/: VCAN_camera.c VCAN_computer.c VCAN_key.c VCAN_LED.C VCAN_OV7725_Eagle.c VCAN_RTC_count.C VCAN_SCCB.c
  group Chip
    ../../Chip/src/: misc.c MK60_adc.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group Lib/FatFs
    ../../Lib/FatFs/: diskio.c ff.c
  group Myfile
    ../../Myfile/: camera.c Debug.c Encoder.c Image.c Line.c Motor.c myKey.c PID.c
  group Ucgui/Config
    Ucgui/Config/: GUI_X.c GUIConf.h GUITouchConf.h LCDConf.h vssver.scc
  group Ucgui/GUI/ConvertMono
    Ucgui/GUI/ConvertMono/: LCDP0.c LCDP2.c LCDP4.c vssver.scc
  group Ucgui/GUI/Core
    Ucgui/GUI/Core/: GUI.h GUI2DLib.c GUI__AddSpaceHex.c GUI__CalcTextRect.c GUI__DivideRound.c GUI__DivideRound32.c GUI__GetFontSizeY.c GUI__GetNumChars.c GUI__HandleEOLine.c GUI__IntersectRect.c GUI__IntersectRects.c GUI__memset.c GUI__memset16.c GUI__Read.c GUI__ReduceRect.c GUI__SetText.c GUI__strcmp.c GUI__strlen.c GUI__Wrap.c GUI_AddBin.c GUI_AddDec.c GUI_AddDecMin.c GUI_AddDecShift.c GUI_AddHex.c GUI_AddKeyMsgHook.c GUI_ALLOC_AllocInit.c GUI_ALLOC_AllocZero.c GUI_BMP.c GUI_BMP_Serialize.c GUI_CalcColorDist.c GUI_ClearRectEx.c GUI_Color2VisColor.c GUI_ConfDefaults.h GUI_CursorArrowL.c GUI_CursorArrowLI.c GUI_CursorArrowLPx.c GUI_CursorArrowM.c GUI_CursorArrowMI.c GUI_CursorArrowMPx.c GUI_CursorArrowS.c GUI_CursorArrowSI.c GUI_CursorArrowSPx.c GUI_CursorCrossL.c GUI_CursorCrossLI.c GUI_CursorCrossLPx.c GUI_CursorCrossM.c GUI_CursorCrossMI.c GUI_CursorCrossMPx.c GUI_CursorCrossS.c GUI_CursorCrossSI.c GUI_CursorCrossSPx.c GUI_CursorHeaderM.c GUI_CursorHeaderMI.c GUI_CursorHeaderMPx.c GUI_CursorPal.c GUI_CursorPalI.c GUI_DispBin.c GUI_DispCEOL.c GUI_DispChar.c GUI_DispChars.c GUI_DispHex.c GUI_DispString.c GUI_DispStringAt.c GUI_DispStringAtCEOL.c GUI_DispStringHCenter.c GUI_DispStringInRect.c GUI_DispStringInRectEx.c GUI_DispStringInRectMax.c GUI_DispStringLen.c GUI_DrawBitmap.c GUI_DrawBitmapEx.c GUI_DrawBitmapExp.c GUI_DrawBitmapMag.c GUI_DrawFocusRect.c GUI_DrawGraph.c GUI_DrawHLine.c GUI_DrawPie.c GUI_DrawPixel.c GUI_DrawPolyline.c GUI_DrawRectEx.c GUI_DrawVLine.c GUI_ErrorOut.c GUI_Exec.c GUI_FillPolygon.c GUI_FillRect.c GUI_FillRectEx.c GUI_FontIntern.h GUI_GetBitmapPixelColor.c GUI_GetBitmapPixelIndex.c GUI_GetClientRect.c GUI_GetColor.c GUI_GetDispPos.c GUI_GetFont.c GUI_GetFontInfo.c GUI_GetFontSizeY.c GUI_GetLineStyle.c GUI_GetStringDistX.c GUI_GetTextAlign.c GUI_GetTextExtend.c GUI_GetTextMode.c GUI_GetVersionString.c GUI_GetYSizeOfFont.c GUI_Goto.c GUI_InitLUT.c GUI_InvertRect.c GUI_IsInFont.c GUI_Log.c GUI_MergeRect.c GUI_MOUSE.c GUI_MOUSE_DriverPS2.c GUI_MoveRect.c GUI_OnKey.c GUI_Pen.c GUI_PID.c GUI_Private.h GUI_Protected.h GUI_RectsIntersect.c GUI_SaveContext.c GUI_SelectLayer.c GUI_SelectLCD.c GUI_SetColor.c GUI_SetColorIndex.c GUI_SetDecChar.c GUI_SetDefault.c GUI_SetDrawMode.c GUI_SetFont.c GUI_SetLBorder.c GUI_SetLineStyle.c GUI_SetLUTColor.c GUI_SetLUTColorEx.c GUI_SetLUTEntry.c GUI_SetOrg.c GUI_SetPixelIndex.c GUI_SetTextAlign.c GUI_SetTextMode.c GUI_SetTextStyle.c GUI_SIF.c GUI_SIF_Prop.c GUI_UC.c GUI_UC_DispString.c GUI_UC_EncodeNone.c GUI_UC_EncodeUTF8.c GUI_VNC.h GUI_WaitEvent.c GUI_WaitKey.c GUI_Warn.c GUI_X.h GUIAlloc.c GUIArc.c GUIChar.c GUICharLine.c GUICharM.c GUICharP.c GUICirc.c GUIColor2Index.c GUICore.c GUICurs.c GUIDebug.h GUIEncJS.c GUIIndex2Color.c GUIPolyE.c GUIPolyM.c GUIPolyR.c GUIRealloc.c GUIStream.c GUITask.c GUITime.c GUITimer.c GUIType.h GUIUC0.c GUIVal.c GUIValf.c GUIVersion.h LCD.c LCD.h LCD_API.c LCD_ConfDefaults.h LCD_DrawBitmap_565.c LCD_DrawBitmap_M565.c LCD_DrawVLine.c LCD_GetColorIndex.c LCD_GetEx.c LCD_GetNumDisplays.c LCD_GetPixelColor.c LCD_Index2ColorEx.c LCD_L0_Generic.c LCD_Mirror.c LCD_MixColors256.c LCD_Private.h LCD_Protected.h LCD_Rotate180.c LCD_RotateCCW.c LCD_RotateCW.c LCD_SelectLCD.c LCD_SetAPI.c LCD_SetClipRectEx.c LCD_UpdateColorIndices.c LCDAA.c LCDColor.c LCDGetP.c LCDInfo.c LCDInfo0.c LCDInfo1.c LCDL0Delta.c LCDL0Mag.c LCDP1.c LCDP565_Index2Color.c LCDPM565_Index2Color.c LCDRLE4.c LCDRLE8.c LCDSIM.h vssver.scc
  group Ucgui/GUI/Font
    Ucgui/GUI/Font/: F6x8.c F8x16.c
  group Ucgui/GUI/LCDDriver
    Ucgui/GUI/LCDDriver/: LCDDummy.c SCAR_OLED.c SCAR_OLED.h
